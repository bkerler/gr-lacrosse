options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rtl_lacrosse
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: TX29U_0
  id: TX29U
  parameters: {}
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '4'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '58'
    interp: '4'
    taps: ''
    type: fff
  states: {}
- name: reveng_pattern_dump
  id: reveng_pattern_dump
  parameters:
    dump_len: 24+8+8+8+8+16
    file_name: ''
    output_fmt: '%Y-%m-%d %H:%M:%S,%[bits]'
    pattern: '[1,0]*16'
    rel_time: 'False'
    stdout: 'False'
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF Gain
    short_id: g
    type: intx
    value: '25'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: 915e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', reveng_pattern_dump, '0']
- [digital_clock_recovery_mm_xx_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [reveng_pattern_dump, out, TX29U_0, in]
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
