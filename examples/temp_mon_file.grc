options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: file_lacrosse
    output_language: python
    run_options: run
  states: {}

blocks:
- name: TX29U_0
  id: TX29U
  parameters: {}
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_name
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*freq_offset/samp_rate
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '4'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: file_name
  id: parameter
  parameters:
    label: File
    short_id: f
    value: ''
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: Frequency Offset
    short_id: o
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '58'
    interp: '4'
    taps: ''
    type: fff
  states: {}
- name: reveng_pattern_dump
  id: reveng_pattern_dump
  parameters:
    dump_len: 24+8+8+8+8+16
    file_name: ''
    output_fmt: '%Y-%m-%d %H:%M:%S,%[bits]'
    pattern: '[1,0]*16'
    rel_time: 'False'
    stdout: 'False'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(1e6)
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', reveng_pattern_dump, '0']
- [digital_clock_recovery_mm_xx_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [reveng_pattern_dump, out, TX29U_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-55-g8526e6f8
